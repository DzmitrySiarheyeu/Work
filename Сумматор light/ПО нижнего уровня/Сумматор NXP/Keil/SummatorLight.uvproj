# Keil uVision project SummatorLight.uvproj, settings and files
target DEBUG (ARM-ADS)
  device: LPC1114/301 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: SummatorLight +hex
  c flags: Optim=1
  c define: DEBUG, byte=uint8_t, IAP_SYS_FREQ=12000
  c misc: --gnu
  c include: ..\Drivers\Freq;..\Drivers\GPIO;..\Drivers\Uart;..\Drivers\WDT;..\Modbus;..\Omnicomm;..\CRC;..\Drivers\ADC;..\Root;..\Dot;..\Fout;..\Led;..\Vout;..\RS_DOT;..\IAP;..\OmniReply;..\CMSIS_LPC11xx\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group StartUp
    ./: startup_LPC11xx.s
    ../CMSIS_LPC11xx/src/: system_LPC11xx.c
  group Freq
    ../Drivers/Freq/: freq.c
  group UART
    ../Drivers/Uart/: uart.c
  group WDT
    ../Drivers/WDT/: wdt.c
  group GPIO
    ../Drivers/GPIO/: gpio.c
  group Modbus
    ../Modbus/: mbclient.c mbfanction0.c
  group Omnicomm
    ../Omnicomm/: omnicomm.c
  group CRC
    ../CRC/: crc8.c crc16.c
  group Root
    ../Root/: main.c
  group DOT
    ../Dot/: dot.c
  group Out
    ../Fout/: fout.c
    ../Vout/: vout.c
  group Led
    ../Led/: errors_led.c
  group IAP
    ../IAP/: sbl_iap.c
  group OmniReply
    ../OmniReply/: reply.c
target RELEASE (ARM-ADS)
  device: LPC1114/302 NXP (founded by Philips)
  cpu: as above
  output: SummatorLight +hex
  c flags: Optim=1
  c define: DEBUG_OFF, byte=uint8_t, IAP_SYS_FREQ=12000
  c misc: --gnu
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1000 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
