# Keil uVision project SumBootloader.uvproj, settings and files
target DEBUG (ARM-ADS)
  device: LPC1114/302 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: SumBootloader +hex
  c flags: Optim=1
  c define: DEBUG, IAP_SYS_FREQ=48000,  CRP_OFF, SystemCoreClock=48000000
  c misc: --gnu
  c include: ..\Keil;..\Bootldr;..\CRC;..\DES;..\IAP;..\UART;..\WDT;..\GPIO
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  link misc: --datacompressor=off
  group StartUp
    ./: startup_LPC11xx.s
  group DES
    ../DES/: des.c
  group CRC
    ../CRC/: CRC.c
  group Boot
    ../Bootldr/: BootLoader.c PreBootLoader.c config.h ISR.c
  group IAP
    ../IAP/: sbl_iap.c
  group Bus
    ../UART/: usart.c
  group WDT
    ../WDT/: wdt.c
  group GPIO
    ../GPIO/: gpio.c
target RELEASE (ARM-ADS)
  device: LPC1114/302 NXP (founded by Philips)
  cpu: as above
  output: SumBootloader +hex
  c flags: Optim=1
  c define: DEBUG_OFF, IAP_SYS_FREQ=48000,  CRP_ON, SystemCoreClock=48000000
  c misc: --gnu
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  link misc: --datacompressor=off
target REL_TEST (ARM-ADS)
  device: LPC1114/302 NXP (founded by Philips)
  cpu: as above
  output: SumBootloader +hex
  c flags: Optim=1
  c define: DEBUG_OFF, IAP_SYS_FREQ=48000,  CRP_OFF, SystemCoreClock=48000000
  c misc: --gnu
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  link misc: --datacompressor=off
