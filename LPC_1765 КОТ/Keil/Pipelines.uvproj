# Keil uVision project Pipelines.uvproj, settings and files
target Ulink (ARM-ADS)
  device: LPC1765 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Pipelines
  c flags: Optim=1
  c define: DEBUG_ON, OSCILLATOR_CLOCK_FREQUENCY=12000000, INIT_ON_, SAVER_INIT_
  c misc: --gnu
  c include: .\Config;.\User;..\Common\debug_system;..\Common\Drivers\FLASH;..\Common\Drivers\Modem;..\Common\Drivers\SSP;..\Common\Drivers\Stats;..\Common\Drivers\UART;..\Common\Drivers;..\Common\Events;..\Common\FAT\Src;..\Common\FAT\Port;..\Common\FTP;..\Common\ParametrsSetting;..\Common\Ports\lwIP;..\Common\Security;..\Common\Sensors;..\Common\Sensors\DataProcFunctions;..\Common\Sensors\PhysProcFunctions;..\Common\Timers;..\Common\VFS;..\Common\WDT;..\FreeRTOS\Source\include;..\lwip\src\include;..\lwip\src\include\ipv4\lwip;..\lwip\src\include\netif;..\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\..\..\..\LPC17XX\LPC1700CMSIS\Drivers\include;..\lwip\src\netif\ppp;..\contrib\ports\FreeRTOS\STR91x;..\lwip\src\include\lwip;..\lwip\src\netif;..\lwip\src\include\ipv4;..\..\..\..\LPC17XX\LPC1700CMSIS\Core\CM3\CoreSupport;..\..\..\..\LPC17XX\LPC1700CMSIS\Core\CM3\DeviceSupport\NXP\LPC17xx;..\Common\MB_client;..\Common\MB_tcp;..\Common\MB_serial;..\Common\MB_server;..\Common\Drivers\MB_server_device;..\Common\HTTP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group debugSystem
    ../Common/debug_system/: debug_system.c Retarget.c
  group VFS
    ../Common/VFS/: at45db161d.c drivers.c sensors.c VFS.c saver_fs.c
  group FreeRTOS
    ../FreeRTOS/Source/: croutine.c list.c queue.c tasks.c
    ../FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/Source/portable/MemMang/: heap_2.c
  group Root
    ./Config/: main.c Config.h FreeRTOSConfig.h lwipopts.h main.h startup_LPC17xx.s
    ./User/: User_Task1.c
  group User
    ./User/: User_Error.c User_Events.c User_Timers.c User_ModBus.c
  group Drivers
    ../Common/Drivers/Modem/: SIM300DZ.c ModemDRV.c
    ../Common/Drivers/SSP/: ssp_lpc17xx.c
    ../Common/Drivers/UART/: uart_lpc17xx.c
    ../Common/Drivers/: DriversCore.c
    ../Common/Drivers/Stats/: All_Stats.c
    ../Common/Drivers/MB_server_device/: MB_server_device.c
    ../Common/Drivers/I2C/: i2c_lpc17xx.c
    ../Common/Drivers/Discrete/: discrete_lpc17xx.c
    ../Common/Drivers/SAVER/: saver.c
    ../Common/Drivers/tcp_redirector/: tcp_redirector.c
    ../Common/Drivers/Clock/: rtc_lpc17xx.c
    ../Common/Drivers/FLASH/: M25PE80.c
    ../Common/Drivers/Impulse/: impulse_lpc17xx.c
  group CMSIS
    ../../../../LPC17XX/LPC1700CMSIS/Drivers/source/: lpc17xx_gpio.c lpc17xx_libcfg_default.c lpc17xx_nvic.c lpc17xx_pinsel.c lpc17xx_ssp.c lpc17xx_systick.c lpc17xx_uart.c lpc17xx_wdt.c lpc17xx_clkpwr.c lpc17xx_timer.c lpc17xx_i2c.c lpc17xx_rtc.c
    ../../../../LPC17XX/LPC1700CMSIS/Core/CM3/DeviceSupport/NXP/LPC17xx/: system_LPC17xx.c
    ../../../../LPC17XX/LPC1700CMSIS/Core/CM3/CoreSupport/: core_cm3.c
  group ParametrSetting
    ../Common/ParametrsSetting/: SetParametrs.c minIni.c
  group Sensors
    ../Common/Sensors/DataProcFunctions/: DataFunc.c
    ../Common/Sensors/PhysProcFunctions/: PhysFunc.c
    ../Common/Sensors/: SensorCore.c
  group Events
    ../Common/Events/: Events.c
  group FAT
    ../Common/FAT/Src/: ff_synk.c ff.c
    ../Common/FAT/Port/: iofat_at25db161a.c
  group FTP
    ../Common/FTP/: ftpd.c
  group HTTP
    ../Common/HTTP/: cookie.c http_cgi.c http_server.c wap.c
  group Telnet
    ../Common/Telnet/: shell.c telnet.c
  group lwIP_Port
    ../Common/Ports/lwIP/: lwIP_sio.c sys_arch.c ping.c usb_netif.c
  group lwIP_API
    ../lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netifapi.c sockets.c tcpip.c
  group lwIP_PPP
    ../lwip/src/netif/ppp/: auth.c fsm.c ipcp.c lcp.c magic.c pap.c ppp.c randm.c
  group lwIP_Core
    ../lwip/src/core/: init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c def.c lwip_timers.c udp.c
    ../lwip/src/core/ipv4/: icmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../lwip/src/netif/: etharp.c
  group Timers
    ../Common/Timers/: timers.c
  group WDT
    ../Common/WDT/: WDT.c
  group Security
    ../Common/Security/: security_lpc17xx.c
  group CRC
    ../Common/CRC/: CRC16.c
  group MB_client
    ../Common/MB_client/: MB_client.c
  group MB_tcp
    ../Common/MB_tcp/: ModbusTCP.c
  group MB_serial
    ../Common/MB_serial/: MB_serial_client.c MB_serial_port.c
  group MB_server
    ../Common/MB_server/: MBServer.c
  group Display
    ../Common/Display/: display_133x64.c LCD 133X65_UC1601S.c
  group Log
    ../Common/Log/: Log.c
  group SMS
    ../Common/SMS/: sms.c
  group USB
    ../Common/Drivers/USB/RNDIS_LUFA/RNDIS_App/: usb_rndis_LPC17xx.c Descriptors.c
    ../Common/Drivers/USB/RNDIS_LUFA/RNDIS_App/_Drivers/USB/Class/Device/: RNDISClassDevice.c
    ../Common/Drivers/USB/RNDIS_LUFA/RNDIS_App/_Drivers/USB/Core/LPC/DCD/LPC17XX/: Endpoint_LPC17xx.c
    ../Common/Drivers/USB/RNDIS_LUFA/RNDIS_App/_Drivers/USB/Core/LPC/HAL/LPC17XX/: HAL_LPC17xx.c
    ../Common/Drivers/USB/RNDIS_LUFA/RNDIS_App/_Drivers/USB/Core/LPC/: Endpoint_LPC.c EndpointStream_LPC.c USBController_LPC.c
    ../Common/Drivers/USB/RNDIS_LUFA/RNDIS_App/_Drivers/USB/Core/: DeviceStandardReq.c USBTask.c
  group CommonTasks
    ../Common/CommonTasks/: ModemTask.c PPPOverDevTask.c UartControlTask.c
target Segger (ARM-ADS)
  device: LPC1765 NXP (founded by Philips)
  cpu: as above
  output: Pipelines +hex
  c flags: Optim=1
  c define: DEBUG, configUSE_IDLE_HOOK = 0, OSCILLATOR_CLOCK_FREQUENCY = 12000000, INIT_ON_, SAVER_INIT_,_PIPELINES_,__LPC17XX__ USB_DEVICE_ONLY
  c misc: --gnu --c99 --diag_suppress=1207,2776
  c include: .\Config;.\User;..\Common\debug_system;..\Common\Drivers\FLASH;..\Common\Drivers\Modem;..\Common\Drivers\SSP;..\Common\Drivers\Stats;..\Common\Drivers\UART;..\Common\Drivers;..\Common\Events;..\Common\FAT\Src;..\Common\FAT\Port;..\Common\FTP;..\Common\ParametrsSetting;..\Common\Ports\lwIP;..\Common\Security;..\Common\Sensors;..\Common\Sensors\DataProcFunctions;..\Common\Sensors\PhysProcFunctions;..\Common\Timers;..\Common\VFS;..\Common\WDT;..\FreeRTOS\Source\include;..\lwip\src\include;..\lwip\src\include\ipv4\lwip;..\lwip\src\include\netif;..\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\..\..\..\LPC17XX\LPC1700CMSIS\Drivers\include;..\lwip\src\netif\ppp;..\contrib\ports\FreeRTOS\STR91x;..\lwip\src\include\lwip;..\lwip\src\netif;..\lwip\src\include\ipv4;..\..\..\..\LPC17XX\LPC1700CMSIS\Core\CM3\CoreSupport;..\..\..\..\LPC17XX\LPC1700CMSIS\Core\CM3\DeviceSupport\NXP\LPC17xx;..\Common\MB_client;..\Common\MB_tcp;..\Common\MB_serial;..\Common\MB_server;..\Common\Drivers\MB_server_device;..\Common\HTTP;..\Common\Drivers\Clock;..\Common\Drivers\I2C;..\Common\Log;..\Common\Display;..\Common\Drivers\Discrete;..\Common\Drivers\SAVER;..\Common\Telnet;..\Common\Drivers\tcp_redirector;..\Common\SMS;..\Common;..\Common\CommonTasks;..\Common\NetBIOS;..\Common\Drivers\USB\RNDIS_LUFA\RNDIS_App;..\Common\Drivers\USB\RNDIS_LUFA\RNDIS_App\_Drivers\USB
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target RELEASE (ARM-ADS)
  device: LPC1765 NXP (founded by Philips)
  cpu: as above
  output: Pipelines_release +hex
  c flags: Optim=1
  c define: DEBUG_OFF, configUSE_IDLE_HOOK = 1, OSCILLATOR_CLOCK_FREQUENCY = 12000000, INIT_ON_, SAVER_INIT_,_PIPELINES_,__LPC17XX__ USB_DEVICE_ONLY,_INT_WDT_,_EXT_WDT_
  c misc: --gnu --c99 --diag_suppress=1207,2776
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x5000 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target DEBUG (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Pipelines +hex
  c flags: Optim=1
  c define: DEBUG_OFF, configUSE_IDLE_HOOK = 1, OSCILLATOR_CLOCK_FREQUENCY = 12000000, INIT_ON_, SAVER_INIT_,_PIPELINES_,__LPC17XX__ USB_DEVICE_ONLY
  c misc: --gnu --c99 --diag_suppress=1207,2776
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  link misc: --no_unaligned_access
